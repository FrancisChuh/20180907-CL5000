# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HRxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_S32K144HFT0VLLT
  c include: ..\SDK\platform\devices;..\SDK\platform\devices\common;..\SDK\platform\devices\S32K144\startup;..\SDK\platform\devices\S32K144\include;..\Generated_Code;..\SDK\platform\drivers\inc;..\SDK\platform\hal\inc;..\SDK\rtos\osif;..\Sources
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HRxxxLLx\S32K144_64_flash.sct
  group Startup
    ../SDK/platform/devices/: startup.c
    ../SDK/platform/devices/S32K144/startup/: system_S32K144.c startup_S32K144.s
  group Generated_Code
    ../Generated_Code/: canCom0.c clockMan1.c Cpu.c crc.c dmaController1.c flash0.c lpuart0.c osif1.c pin_mux.c
  group SDK
    ../SDK/platform/drivers/src/clock/: clock_manager.c
    ../SDK/platform/drivers/src/clock/S32K144/: clock_S32K144.c
    ../SDK/platform/drivers/src/crc/: crc_driver.c
    ../SDK/platform/drivers/src/edma/: edma_common.c edma_driver.c edma_irq.c
    ../SDK/platform/drivers/src/flash/: flash_driver.c
    ../SDK/platform/drivers/src/flexcan/: flexcan_common.c flexcan_driver.c flexcan_irq.c
    ../SDK/platform/drivers/src/interrupt/: interrupt_manager.c
    ../SDK/platform/drivers/src/lpuart/: lpuart_common.c lpuart_driver.c lpuart_irq.c
    ../SDK/platform/drivers/src/pins/: pins_driver.c
    ../SDK/platform/hal/src/crc/: crc_hal.c
    ../SDK/platform/hal/src/dmamux/: dmamux_hal.c
    ../SDK/platform/hal/src/edma/: edma_hal.c
    ../SDK/platform/hal/src/flexcan/: flexcan_hal.c
    ../SDK/platform/hal/src/lpuart/: lpuart_hal.c
    ../SDK/platform/hal/src/pcc/: pcc_hal.c
    ../SDK/platform/hal/src/pmc/: pmc_hal.c
    ../SDK/platform/hal/src/port/: port_hal.c
    ../SDK/platform/hal/src/scg/: scg_hal.c
    ../SDK/platform/hal/src/sim/S32K144/: sim_hal_S32K144.c
    ../SDK/platform/hal/src/smc/: smc_hal.c
    ../SDK/rtos/osif/: osif_baremetal.c
  group Sources
    ../Sources/: main.c mfalsh.c mflexcan.c update.c xmodem.c
software components: CMSIS:CORE 5.1.1
