# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HRxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Driver;..\User;..\Service
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HRxxxLLx\S32K144_64_flash.sct
  group Driver
    ../Driver/: S32_can.c S32_gpio.c S32_PIT.c S32K_adc.c S32K_FTM.c S32K_uart.c
  group User
    ../User/: B31.c delay.c key.c Key_Proc.c KeyFunction.c main.c B31_Config.c
  group Service
    ../Service/: adc.c can.c E_MOTOR_DRIVE.c Fan_Temp_Mode.c FLASH.c FlexRam.C GPIO.c IRQ.c LIN.c LINprotocol.c modules_switch.c MOTOR_DRIVE.c pit.c PM25.c process.c pwm.c SPI.c TB9102.c Tem_Hum.c temper.c TPD1053.c uart.c wdog.c Fan.c TJA1021T.c uart_lin.c APTC.c WPTC.c CPC.c compressor.c CAN_Protocol.c CGW_Input.c actuator.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.0.0
