# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HRxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_S32K144HFT0VLLT
  c include: ..\Generated_Code;..\SDK\middleware\sbc\sbc_uja1169\include;..\SDK\platform\drivers\inc;..\SDK\rtos\osif;..\SDK\platform\pal\can\inc;.\RTE\Device\S32K144HRxxxLLx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HRxxxLLx\S32K144_64_flash.sct
  group Startup
    ./RTE/Device/S32K144HRxxxLLx/: startup.c system_S32K144.c startup_S32K144.s
  group SDK
    ../SDK/middleware/sbc/sbc_uja1169/source/: sbc_uja1169_driver.c
    ../SDK/platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c
    ../SDK/platform/drivers/src/clock/: clock_manager.c
    ../SDK/platform/drivers/src/edma/: edma_driver.c edma_hw_access.c edma_irq.c
    ../SDK/platform/drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_irq.c
    ../SDK/platform/drivers/src/interrupt/: interrupt_manager.c
    ../SDK/platform/drivers/src/lpspi/: lpspi_hw_access.c lpspi_irq.c lpspi_master_driver.c lpspi_shared_function.c lpspi_slave_driver.c
    ../SDK/platform/drivers/src/pins/: pins_driver.c pins_port_hw_access.c
    ../SDK/platform/pal/can/src/: can_pal.c
    ../SDK/rtos/osif/: osif_baremetal.c
  group Generated_Code
    ../Generated_Code/: can_pal1.c clockMan1.c Cpu.c dmaController1.c lpspiCom1.c pin_mux.c sbc_uja11691.c
  group Sources
    ../Sources/: main.c
software components: CMSIS:CORE 5.1.1
