# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HRxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_S32K144HFT0VLLT
  c include: ..\src;.\RTE\Device\S32K144HRxxxLLx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HRxxxLLx\S32K144_64_flash.sct
  group Startup
    ./RTE/Device/S32K144HRxxxLLx/: startup.c system_S32K144.c startup_S32K144.s
  group src
    ../src/: clocks_and_modes.c FlexCAN.c LPSPI.c main.c
software components: CMSIS:CORE 5.1.1
